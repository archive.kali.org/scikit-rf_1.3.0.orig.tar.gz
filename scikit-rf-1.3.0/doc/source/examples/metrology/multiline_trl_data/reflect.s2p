!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (one-way two-port):
!   201 points, 1 GHz to 100 GHz, reference 50 ohm
!   highest |S21| = -50.54 dB at 45.55 GHz (marker M1); lowest = -105.2 dB at 13.87 GHz (marker M2)
!   lowest |S11| = -13.8 dB at 96.53 GHz (marker M3), VSWR 1.51, Z = 33.3 + j3.36 ohm
!   |S11| at or under -10 dB: 73.19 GHz to 73.97 GHz (780.1 MHz wide, 1.06 % of centre); 91 GHz to 92.2 GHz (1.194 GHz wide, 1.3 % of centre); 95.75 GHz to 97.24 GHz (1.486 GHz wide, 1.54 % of centre) (the widest 3 of 28)
!   |S22| runs from -17.0 to -1.3 dB; largest |S21 - S12| = 0.0044
!   the Smith chart shows 93.56 GHz to 100 GHz only
!   S11 on the Smith chart (normalised r, x): 93.56 GHz: 0.89, +0.52; 96.53 GHz: 0.67, +0.07; 97.53 GHz: 1.52, -0.66; 99.01 GHz: 1.94, -0.27; 100 GHz: 0.77, +0.35
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 1 GHz  -1.1  -54.6  -57.0  -1.4
! 3.475 GHz  -2.3  -86.6  -61.4  -3.0
! 8.92 GHz  -2.9  -59.9  -80.6  -4.7
! 11.89 GHz  -3.7  -82.8  -55.5  -4.3
! 13.38 GHz  -4.2  -54.0  -52.5  -4.0
! 13.87 GHz  -3.7  -105.2  -80.8  -4.3
! 17.83 GHz  -5.6  -62.8  -57.0  -4.6
! 34.16 GHz  -7.8  -65.0  -62.7  -7.4
! 41.59 GHz  -6.3  -54.6  -71.9  -7.4
! 42.09 GHz  -7.5  -81.5  -53.2  -6.9
! 43.57 GHz  -7.0  -53.5  -63.4  -8.1
! 45.05 GHz  -6.6  -86.5  -59.2  -9.7
! 45.55 GHz  -8.7  -50.5  -66.1  -8.5
! 46.05 GHz  -8.2  -76.0  -68.4  -6.8
! 50.5 GHz  -9.4  -58.9  -57.4  -10.9
! 67.33 GHz  -9.9  -65.0  -63.4  -8.3
! 83.67 GHz  -11.3  -75.1  -63.5  -8.8
! 93.56 GHz  -11.3  -63.2  -57.2  -14.0
! 96.53 GHz  -13.8  -60.1  -81.3  -16.6
! 97.53 GHz  -9.8  -89.3  -76.5  -12.7
! 99.01 GHz  -9.6  -70.2  -63.0  -15.8
! 100 GHz  -12.7  -70.7  -55.4  -10.1
